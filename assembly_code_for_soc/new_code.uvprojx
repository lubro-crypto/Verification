# Keil uVision project new_code.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: new_code
  AfterMake: fromelf -cvf "C:\Users\TejMi\OneDrive - Imperial College London\Desktop\YR4\Hardware & software verification\HW Verification Coursework\new_code_uart\Objects\new_code.axf" --vhx --32x1 -o "C:\Users\TejMi\OneDrive - Imperial College London\Desktop\YR4\Hardware & software verification\HW Verification Coursework\new_code_uart\Objects\new_code.hex"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: new_code.s
